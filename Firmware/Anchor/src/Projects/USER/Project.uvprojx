# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ../USER;../LIB/inc;../CMSIS;../../Components/OSAL;../../Components/HAL;../../Components/APP;../../Components/HAL/USB/src;../../Components/HAL/USB/lib;../../Components/HAL/DW/dw_twr;../../Components/HAL/DW/decadriver;../../Components/Main;../../Components/HAL/DW/dw_twr/examples/ex_00a_reading_dev_id;../../Components/HAL/DW/dw_twr/examples/ex_01a_simple_tx;../../Components/HAL/DW/dw_twr/examples/ex_00a_reading_dev_id;../../Components/HAL/DW/dw_twr/examples/ex_01b_tx_sleep;../../Components/HAL/DW/dw_twr/examples/ex_01c_tx_sleep_auto;../../Components/HAL/DW/dw_twr/examples/eex_01d_tx_timed_sleep;../../Components/HAL/DW/dw_twr/examples/ex_01e_tx_with_cca;../../Components/HAL/DW/dw_twr/examples/ex_01g_simple_tx_sts_sdc;../../Components/HAL/DW/dw_twr/examples/ex_01h_simple_tx_pdoa;../../Components/HAL/DW/dw_twr/examples/ex_01i_simple_tx_aes;../../Components/HAL/DW/dw_twr/examples/ex_01c_tx_sleep_auto;../../Components/HAL/DW/dw_twr/examples/ex_02a_simple_rx;../../Components/HAL/DW/dw_twr/examples/ex_02c_rx_diagnostics;../../Components/HAL/DW/dw_twr/examples/ex_02d_rx_sniff;../../Components/HAL/DW/dw_twr/examples/ex_02f_rx_with_crystal_trim;../../Components/HAL/DW/dw_twr/examples/ex_02g_simple_rx_sts_sdc;../../Components/HAL/DW/dw_twr/examples/ex_02h_simple_rx_pdoa;../../Components/HAL/DW/dw_twr/examples/ex_02i_simple_rx_aes;../../Components/HAL/DW/dw_twr/examples/ex_03a_tx_wait_resp;../../Components/HAL/DW/dw_twr/examples/ex_03b_rx_send_resp;../../Components/HAL/DW/dw_twr/examples/ex_03d_tx_wait_resp_interrupts;../../Components/HAL/DW/dw_twr/examples/ex_04a_cont_wave;../../Components/HAL/DW/dw_twr/examples/ex_04b_cont_frame;../../Components/HAL/DW/dw_twr/examples/ex_05a_ds_twr_init;../../Components/HAL/DW/dw_twr/examples/ex_05b_ds_twr_resp;../../Components/HAL/DW/dw_twr/examples/ex_05c_ds_twr_init_sts_sdc;../../Components/HAL/DW/dw_twr/examples/ex_05d_ds_twr_resp_sts_sdc;../../Components/HAL/DW/dw_twr/examples/ex_06a_ss_twr_initiator;../../Components/HAL/DW/dw_twr/examples/ex_06b_ss_twr_responder;../../Components/HAL/DW/dw_twr/examples/ex_06e_AES_ss_twr_initiator;../../Components/HAL/DW/dw_twr/examples/ex_06f_AES_ss_twr_responder;../../Components/HAL/DW/dw_twr/examples/ex_07a_ack_data_tx;../../Components/HAL/DW/dw_twr/examples/ex_07b_ack_data_rx;../../Components/HAL/DW/dw_twr/examples/ex_07c_ack_data_rx_dbl_buff;../../Components/HAL/DW/dw_twr/examples/ex_11a_spi_crc;../../Components/HAL/DW/dw_twr/examples/ex_13a_gpio;../../Components/HAL/DW/dw_twr/examples/ex_14_otp_write;../../Components/HAL/DW/dw_twr/examples/ex_15_le_pend;../../Components/HAL/DW/dw_twr/examples/examples_info;../../Components/HAL/DW/dw_twr/examples/shared_data;../../Components/HAL/OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../../Components/APP/: cmd.c cmd_fn.c Generic.c Generic_cmd.c
  group HAL
    ../../Components/HAL/: hal_led.c hal_drivers.c hal_timer.c hal_usart.c hal_flash.c hal_spi.c hal_iic.c hal_usb.c
  group OSAL
    ../../Components/OSAL/: OSAL_Comdef.h OSAL.c
  group ZMain
    ../../Components/Main/: main.c stm32f10x_it.c
  group DW/PDoA
    ../../Components/HAL/DW/dw_twr/: twr_task.c config_options.c uwb.c config.c json_2pc.c tag_list.c
    ../../Components/HAL/DW/dw_twr/examples/examples_info/: example_info.c
  group DW/Driver
    ../../Components/HAL/DW/dw_twr/: deca_mutex.c
    ../../Components/HAL/DW/decadriver/: deca_device.c
  group DW/Examples
    ../../Components/HAL/DW/dw_twr/examples/ex_05d_ds_twr_resp_sts_sdc/: ds_twr_sts_sdc_responder.c
    ../../Components/HAL/DW/dw_twr/examples/shared_data/: shared_functions.c
    ../../Components/HAL/DW/dw_twr/: mac_802_15_4.c mac_802_15_8.c
  group USB
    ../../Components/HAL/USB/src/: hw_config.c Queue.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
  group USB/Lib
    ../../Components/HAL/USB/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group OLED
    ../../Components/HAL/OLED/: OLED_I2C.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
